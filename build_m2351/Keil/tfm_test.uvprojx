# Keil uVision project tfm_test.uvprojx, settings and files
target tfm_test (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: ../../../build/app/secure_fw/tfm_s
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: TFM_LVL=1
  c misc: -DMBEDTLS_CONFIG_FILE=\"tfm_mbedtls_config.h\" -include mbedtls_global_symbols.h -DLIB_PREFIX_NAME=__tfm_crypto__
  c include: ..\..\..\..\..\..\..\mbedtls\include;..\..\..\..\..\..\secure_fw\services\secure_storage\crypto;..\..\..\..\common;..\..\..\..\..\..\interface\include;..\..\..\..\..\..\secure_fw\core;..\cmsis_core;..\..\..\..\cmsis;..\retarget
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target attach (6100001::V6.10.1::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: as above
  output: ../../app/secure_fw/tfm_s
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: TFM_LVL=1
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
